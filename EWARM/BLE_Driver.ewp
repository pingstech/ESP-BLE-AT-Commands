# IAR project BLE_Driver.ewp, settings and files
configuration BLE_Driver (ARM, debug)
  General.OGChipSelectEditMenu: STM32G0B1KB ST STM32G0B1KB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G0B1xx
  ICCARM.CCIncludePath2: ..; ..\esp_multiple_connection_project; ..\esp_multiple_connection_project\ble; ..\esp_multiple_connection_project\ble\api; ..\esp_multiple_connection_project\ble\app; ..\esp_multiple_connection_project\tcp; ..\esp_multiple_connection_project\queue; ..\hardware; ..\third_party; ..\third_party\CMSIS; ..\third_party\STM32G0xx_HAL_Driver; ..\third_party\Core_Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_Driver.bin
  ILINK.IlinkOutputFile: BLE_Driver.out
  ILINK.IlinkIcfFile: stm32g0b1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: main.c main.h
  group Application/EWARM
    ./: startup_stm32g0b1xx.s
  group esp_multiple_connection_project/ble/api
    ../esp_multiple_connection_project/ble/api/: ble_api.c ble_api.h
  group esp_multiple_connection_project/ble/app
    ../esp_multiple_connection_project/ble/app/: ble_app.c ble_app.h
  group esp_multiple_connection_project/queue
    ../esp_multiple_connection_project/queue/: queue.c queue.h
  group hardware
    ../hardware/: hardware_init.c hardware_init.h stm32g0xx_hal_conf.h stm32g0xx_hal_msp.c stm32g0xx_it.c stm32g0xx_it.h system_stm32g0xx.c
  group third_party/CMSIS
    ../third_party/CMSIS/: stm32g0b1xx.h stm32g0xx.h system_stm32g0xx.h
  group third_party/Core_Include
    ../third_party/Core_Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
  group third_party/STM32G0xx_HAL_Driver
    ../third_party/STM32G0xx_HAL_Driver/: stm32_hal_legacy.h stm32g0xx_hal.c stm32g0xx_hal.h stm32g0xx_hal_cortex.c stm32g0xx_hal_cortex.h stm32g0xx_hal_def.h stm32g0xx_hal_dma.c stm32g0xx_hal_dma.h stm32g0xx_hal_dma_ex.c stm32g0xx_hal_dma_ex.h stm32g0xx_hal_exti.c stm32g0xx_hal_exti.h stm32g0xx_hal_flash.c stm32g0xx_hal_flash.h stm32g0xx_hal_flash_ex.c stm32g0xx_hal_flash_ex.h stm32g0xx_hal_gpio.c stm32g0xx_hal_gpio.h stm32g0xx_hal_gpio_ex.h stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr.h stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_pwr_ex.h stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc.h stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_rcc_ex.h stm32g0xx_hal_uart.c stm32g0xx_hal_uart.h stm32g0xx_hal_uart_ex.c stm32g0xx_hal_uart_ex.h stm32g0xx_ll_bus.h stm32g0xx_ll_cortex.h stm32g0xx_ll_crs.h stm32g0xx_ll_dma.c stm32g0xx_ll_dma.h stm32g0xx_ll_dmamux.h stm32g0xx_ll_exti.h stm32g0xx_ll_gpio.h stm32g0xx_ll_lpuart.h stm32g0xx_ll_pwr.h stm32g0xx_ll_rcc.c stm32g0xx_ll_rcc.h stm32g0xx_ll_system.h stm32g0xx_ll_usart.h stm32g0xx_ll_utils.h
